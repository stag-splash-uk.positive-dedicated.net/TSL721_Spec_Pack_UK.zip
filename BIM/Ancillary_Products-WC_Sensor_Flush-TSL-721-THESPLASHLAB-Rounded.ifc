Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2018-03-01T00:35:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160314_0715(x64) - Exporter 16.0.1124.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 01 00:35:17 2018 * Host: DESKTOP-HSFH8JC * Database: C:\Users\C559~1\AppData\Local\Temp\{794CE79E-5C16-4847-82C4-A69E7C273E96}\ifc * Database version: 5507 * Database creation date: Thu Mar 01 00:35:17 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 01 00:35:17 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 01 00:35:17 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: TSL-721_black, Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded:TSL-721_black:315695
In: Level 1
Type - Classification: D5030800 Security & Detection Systems (Uniformat); Material: Brushed Black, Glass-Lovair-Smoked
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: D5030800; Assembly Description: Security & Detection Systems; Description: The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls. The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls.; DocumentationInstallationGuide: www.thesplashlab.com; DocumentationLiterature: www.thesplashlab.com; DocumentationMaintenance: www.thesplashlab.com; DocumentationTechnical: www.thesplashlab.com; Keynote: W; Manufacturer: TheSplashLab; Model: TSL-721; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Documentation Link: www.thesplashlab.com; Product O&M Link: www.thesplashlab.com; Product Page Link: www.thesplashlab.com; Product Specification Link: www.thesplashlab.com; Type Comments: Brushed Black; Type Name: TSL-721_black; URL: www.thesplashlab.com
Type - Materials and Finishes - finish: Brushed Black
Type - Other - Category: Electrical Fixtures; _BIMspec_GUID: 0; _current revision: 1; Family Name: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0
Type - Text - _created by: www.thesplashlab.com; CreatedBy: www.thesplashlab.com; CreatedOn: 'February 2015'; DurationUnit: Years; ExpectedLife: 2; Finish: Brushed Black; Grade: 304; Material: Stainless Steel; ModelNumber: TSL-721; Mtrl_Finish: Brushed Black; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; Mtrl_TypeName: TSL-721; NBSObjectName: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded; Uniclass2: Pr_40_20_93_91; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 12; WarrantyDurationUnit: months; WarrantyGuarantorParts: email: technical@thesplashlab.com
Pset_BuildingElementProxyCommon - Reference: TSL-721_black
Pset_ManufacturerTypeInformation - Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.00778761 m2; Volume: 0.0000508676 m3
Identity Data - Mark: 1
Other - Family: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_black; Family and Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_black; Schedule Level: Level: Level 1; Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_black; Type Id: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_black
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: TSL-721_brass, Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded:TSL-721_brass:315705
In: Level 1
Type - Classification: D5030800 Security & Detection Systems (Uniformat); Material: Brushed Brass, Glass-Lovair-Smoked
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: D5030800; Assembly Description: Security & Detection Systems; Description: The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls. The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls.; DocumentationInstallationGuide: www.thesplashlab.com; DocumentationLiterature: www.thesplashlab.com; DocumentationMaintenance: www.thesplashlab.com; DocumentationTechnical: www.thesplashlab.com; Keynote: W; Manufacturer: TheSplashLab; Model: TSL-721; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Documentation Link: www.thesplashlab.com; Product O&M Link: www.thesplashlab.com; Product Page Link: www.thesplashlab.com; Product Specification Link: www.thesplashlab.com; Type Comments: Brushed Brass; Type Name: TSL-721_brass; URL: www.thesplashlab.com
Type - Materials and Finishes - finish: Brushed Brass
Type - Other - Category: Electrical Fixtures; _BIMspec_GUID: 0; _current revision: 1; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0; Family Name: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded
Type - Text - ExpectedLife: 2; _created by: www.thesplashlab.com; CreatedBy: www.thesplashlab.com; CreatedOn: 'February 2015'; DurationUnit: Years; Finish: Brushed Brass; Grade: 304; Material: Stainless Steel; ModelNumber: TSL-721; Mtrl_Finish: Brushed Brass; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; Mtrl_TypeName: TSL-721; NBSObjectName: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded; Uniclass2: Pr_40_20_93_91; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 12; WarrantyDurationUnit: months; WarrantyGuarantorParts: email: technical@thesplashlab.com
Pset_BuildingElementProxyCommon - Reference: TSL-721_brass
Pset_ManufacturerTypeInformation - Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00778761 m2; Volume: 0.0000508676 m3
Identity Data - Mark: 2
Other - Schedule Level: Level: Level 1; Family: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_brass; Family and Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_brass; Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_brass; Type Id: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_brass
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: TSL-721_bronze, Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded:TSL-721_bronze:315715
In: Level 1
Type - Classification: D5030800 Security & Detection Systems (Uniformat); Material: Brushed Bronze, Glass-Lovair-Smoked
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: D5030800; Assembly Description: Security & Detection Systems; Description: The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls. The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls.; DocumentationInstallationGuide: www.thesplashlab.com; DocumentationLiterature: www.thesplashlab.com; DocumentationMaintenance: www.thesplashlab.com; DocumentationTechnical: www.thesplashlab.com; Keynote: W; Manufacturer: TheSplashLab; Model: TSL-721; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Documentation Link: www.thesplashlab.com; Product O&M Link: www.thesplashlab.com; Product Page Link: www.thesplashlab.com; Product Specification Link: www.thesplashlab.com; Type Comments: Brushed Bronze; Type Name: TSL-721_bronze; URL: www.thesplashlab.com
Type - Materials and Finishes - finish: Brushed Bronze
Type - Other - Category: Electrical Fixtures; _BIMspec_GUID: 0; _current revision: 1; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0; Family Name: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded
Type - Text - ExpectedLife: 2; _created by: www.thesplashlab.com; CreatedBy: www.thesplashlab.com; CreatedOn: 'February 2015'; DurationUnit: Years; Finish: Brushed Bronze; Grade: 304; Material: Stainless Steel; ModelNumber: TSL-721; Mtrl_Finish: Brushed Bronze; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; Mtrl_TypeName: TSL-721; NBSObjectName: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded; Uniclass2: Pr_40_20_93_91; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 12; WarrantyDurationUnit: months; WarrantyGuarantorParts: email: technical@thesplashlab.com
Pset_BuildingElementProxyCommon - Reference: TSL-721_bronze
Pset_ManufacturerTypeInformation - Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00778761 m2; Volume: 0.0000508676 m3
Identity Data - Mark: 3
Other - Schedule Level: Level: Level 1; Family: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_bronze; Family and Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_bronze; Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_bronze; Type Id: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_bronze
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: TSL-721_copper, Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded:TSL-721_copper:315725
In: Level 1
Type - Classification: D5030800 Security & Detection Systems (Uniformat); Material: Brushed Copper, Glass-Lovair-Smoked
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: D5030800; Assembly Description: Security & Detection Systems; Description: The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls. The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls.; DocumentationInstallationGuide: www.thesplashlab.com; DocumentationLiterature: www.thesplashlab.com; DocumentationMaintenance: www.thesplashlab.com; DocumentationTechnical: www.thesplashlab.com; Keynote: W; Manufacturer: TheSplashLab; Model: TSL-721; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Documentation Link: www.thesplashlab.com; Product O&M Link: www.thesplashlab.com; Product Page Link: www.thesplashlab.com; Product Specification Link: www.thesplashlab.com; Type Comments: Brushed Copper; Type Name: TSL-721_copper; URL: www.thesplashlab.com
Type - Materials and Finishes - finish: Brushed Copper
Type - Other - Category: Electrical Fixtures; _BIMspec_GUID: 0; _current revision: 1; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0; Family Name: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded
Type - Text - ExpectedLife: 2; _created by: www.thesplashlab.com; CreatedBy: www.thesplashlab.com; CreatedOn: 'February 2015'; DurationUnit: Years; Finish: Brushed Copper; Grade: 304; Material: Stainless Steel; ModelNumber: TSL-721; Mtrl_Finish: Brushed Copper; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; Mtrl_TypeName: TSL-721; NBSObjectName: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded; Uniclass2: Pr_40_20_93_91; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 12; WarrantyDurationUnit: months; WarrantyGuarantorParts: email: technical@thesplashlab.com
Pset_BuildingElementProxyCommon - Reference: TSL-721_copper
Pset_ManufacturerTypeInformation - Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00778761 m2; Volume: 0.0000508676 m3
Identity Data - Mark: 4
Other - Schedule Level: Level: Level 1; Family: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_copper; Family and Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_copper; Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_copper; Type Id: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_copper
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: TSL-721_steel, Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded:TSL-721_steel:315735
In: Level 1
Type - Classification: D5030800 Security & Detection Systems (Uniformat); Material: Brushed Stainless Steel, Glass-Lovair-Smoked
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: D5030800; Assembly Description: Security & Detection Systems; Description: The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls. The TSL-721 is a wave operated WC sensor flush kit for integrated plumbing applications, and includes all related cabling and controls.; DocumentationInstallationGuide: www.thesplashlab.com; DocumentationLiterature: www.thesplashlab.com; DocumentationMaintenance: www.thesplashlab.com; DocumentationTechnical: www.thesplashlab.com; Keynote: W; Manufacturer: TheSplashLab; Model: TSL-721; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Documentation Link: www.thesplashlab.com; Product O&M Link: www.thesplashlab.com; Product Page Link: www.thesplashlab.com; Product Specification Link: www.thesplashlab.com; Type Comments: Stainless Steel; Type Name: TSL-721_steel; URL: www.thesplashlab.com
Type - Materials and Finishes - finish: Brushed Stainless Steel
Type - Other - Category: Electrical Fixtures; _BIMspec_GUID: 0; _current revision: 1; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0; Family Name: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded
Type - Text - ExpectedLife: 2; _created by: www.thesplashlab.com; CreatedBy: www.thesplashlab.com; CreatedOn: 'February 2015'; DurationUnit: Years; Finish: Stainless Steel; Grade: 304; Material: Stainless Steel; ModelNumber: TSL-721; Mtrl_Finish: Stainless Steel; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; Mtrl_TypeName: TSL-721; NBSObjectName: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded; Uniclass2: Pr_40_20_93_91; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 12; WarrantyDurationUnit: months; WarrantyGuarantorParts: email: technical@thesplashlab.com
Pset_BuildingElementProxyCommon - Reference: TSL-721_steel
Pset_ManufacturerTypeInformation - Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00778761 m2; Volume: 0.0000508676 m3
Identity Data - Mark: 5
Other - Schedule Level: Level: Level 1; Family: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_steel; Family and Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_steel; Type: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_steel; Type Id: Ancillary_Products-WC_Sensor_Flush-TSL-721-THESPLASHLAB-Rounded: TSL-721_steel
Phasing - Phase Created: New Construction
